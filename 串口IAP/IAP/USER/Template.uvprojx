# Keil uVision project Template.uvprojx, settings and files
target Template (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HAREWARE;..\HAREWARE\LED;..\HAREWARE\KEY;..\HAREWARE\LCD;..\HAREWARE\STMFLASH;..\HAREWARE\IAP
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
  group README
    ../: README.TXT
  group HAREWARE
    ../HAREWARE/LED/: led.c
    ../HAREWARE/LCD/: lcd.c
    ../HAREWARE/KEY/: key.c
    ../HAREWARE/STMFLASH/: stmflash.c
  group IAP
    ../HAREWARE/IAP/: iap.c
