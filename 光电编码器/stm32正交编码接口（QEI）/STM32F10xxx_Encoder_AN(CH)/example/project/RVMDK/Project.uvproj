# Keil uVision project Project.uvproj, settings and files
target BOOT_FLASH (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: BOOT_FLASH
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: VECT_TAB_FLASH
  c include: ..\..\project;..\..\library\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../: stm32f10x_it.c main.c
  group FWLib
    ../../library/src/: stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim1.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group RVMDK
    ./: stm32f10x_vector.s cortexm3_macro.s
  group Doc
    ./: readme.txt
target BOOT_RAM (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  cpu: as above
  output: BOOT_RAM
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: VECT_TAB_RAM
  c include: ..\..\project;..\..\library\inc
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x3000
  memory RVCT9: RAM 0x20003000 size 0x2000
