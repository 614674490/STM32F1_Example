# Keil uVision project TEST.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TEST +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\SYSTEM\delay;..\CORE;..\STM3210X\inc;..\FWLIB\KEY;..\SYSTEM\usart;..\FWLIB\LED;..\FWLIB\TIMER;..\SYSTEM\sys;..\STM3210X\src;..\FWLIB\DMA;..\FWLIB\USART1
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
    ../STM3210X/src/: stm32f10x_dma.c
  group STM3210X
    ../STM3210X/src/: misc.c stm32f10x_usart.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c
  group FWLIB
    ../FWLIB/LED/: led.c
    ../FWLIB/TIMER/: timer.c
    ../FWLIB/DMA/: dma.c
    ../FWLIB/USART1/: usart1.c
